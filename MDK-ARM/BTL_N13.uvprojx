# Keil uVision project BTL_N13.uvprojx, settings and files
target BTL_N13_STM32F103C8 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IROM(0x08000000,0x00010000) IRAM(0x20000000,0x00005000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: BTL_N13 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F103xB,STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\bsp\inc;..\hal\inc;..\app\inc;..\middlewares\FreeRTOS\config;..\vendor\CMSIS\Include;..\vendor\STM32F10x_SPL\inc;..\vendor\STM32F10x_SPL\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\middlewares\FreeRTOS\Source\include;..\middlewares\FreeRTOS\Source\portable\RVDS\ARM_CM3
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: BTL_N13.sct
  group Root
    ../: main.c
  group app/inc
    ../app/inc/: app_config.h app_ipc.h task_alarm.h task_button.h task_oled.h task_sensor.h
  group app/src
    ../app/src/: app_ipc.c task_alarm.c task_button.c task_oled.c task_sensor.c
  group bsp/inc
    ../bsp/inc/: bsp_board.h bsp_pins.h
  group hal/inc
    ../hal/inc/: hal_gpio.h hal_i2c.h ssd1306.h stm32f10x_conf.h
  group hal/src
    ../hal/src/: hal_gpio.c hal_i2c.c hal_stm32f103.c ssd1306.c startup_stm32f10x_md.s
  group middlewares/FreeRTOS/config
    ../middlewares/FreeRTOS/config/: FreeRTOSConfig.h
  group middlewares/FreeRTOS/Source
    ../middlewares/FreeRTOS/Source/: event_groups.c list.c queue.c tasks.c timers.c
  group middlewares/FreeRTOS/Source/include
    ../middlewares/FreeRTOS/Source/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group middlewares/FreeRTOS/Source/portable/MemMang
    ../middlewares/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group middlewares/FreeRTOS/Source/portable/RVDS/ARM_CM3
    ../middlewares/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c portmacro.h
  group vendor/CMSIS/Include
    ../vendor/CMSIS/Include/: arm_common_tables.h arm_const_structs.h arm_helium_utils.h arm_math.h arm_mve_tables.h arm_vec_math.h cachel1_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv81mml.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm1.h core_cm23.h core_cm3.h core_cm33.h core_cm35p.h core_cm4.h core_cm55.h core_cm7.h core_sc000.h core_sc300.h mpu_armv7.h mpu_armv8.h pmu_armv8.h tz_context.h
  group vendor/STM32F10x_SPL/CMSIS/CM3/DeviceSupport/ST/STM32F10x
    ../vendor/STM32F10x_SPL/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: stm32f10x.h system_stm32f10x.h
  group vendor/STM32F10x_SPL/inc
    ../vendor/STM32F10x_SPL/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group vendor/STM32F10x_SPL/src
    ../vendor/STM32F10x_SPL/src/: misc.c stm32f10x_adc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c
